<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\14-TIMER_Clock_ADC_butt.ewp</path>
  </project>
  <batchBuild />
</workspace>
